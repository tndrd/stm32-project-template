# IAR project stm32++.ewp, settings and files
configuration stm32f207 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207ZG ST STM32F207ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F2XX
  ICCARM.CCIncludePath2: lib\CMSIS\Device\ST\STM32F2xx\Include; lib\STM32F207_StdPeriph_Driver\inc; src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  postbuild: cmd /C start /D "doxygen" doxygen Doxyfile
  ILINK.IlinkOutputFile: stm32++_IAR_9.out
configuration stm32f373xB (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F373VB ST STM32F373VB
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F37X
  ICCARM.CCIncludePath2: lib\CMSIS\Device\ST\STM32F37x\Include; lib\STM32F373_StdPeriph_Driver\inc; src
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f373xB_no-exceptions_no-rtti (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F373VB ST STM32F373VB
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F37X; NO_EXCEPTIONS; NO_RTTI
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f407zg (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx
  ICCARM.CCIncludePath2: lib\CMSIS\Device\ST\STM32F4xx\Include; lib\STM32F407_StdPeriph_Driver\inc; src
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f407vg (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx
  ICCARM.CCIncludePath2: lib\CMSIS\Device\ST\STM32F4xx\Include; lib\STM32F4x7_ETH_Driver\inc; lib\stm32_mw_lwip\src\include; lib\stm32_mw_lwip\system; src; src\ethernet
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f427ii (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F427II ST STM32F427II
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F427_437xx
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f429zi (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F429xx
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f446 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F446RC ST STM32F446RC
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F446xx
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32l476rg (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx
  ICCARM.CCIncludePath2: src
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32g474 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32G474RE ST STM32G474RE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32G474xx
  ICCARM.CCIncludePath2: src
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f303xC (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F303xC
  ICCARM.CCIncludePath2: lib\CMSIS\Device\ST\cmsis_device_f3\Include; src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f303x8 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F303C8 ST STM32F303C8
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F303x8
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f030x6 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F030K6 ST STM32F030K6
  General.CoreVariant: 34
  ICCARM.CCDefines: STM32F030x6; STM32F0
  ICCARM.CCIncludePath2: lib\CMSIS\Device\ST\STM32F0xx\Include; src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f767 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F767xx
  ICCARM.CCIncludePath2: lib\CMSIS\Device\ST\cmsis_device_f7\Include; lib\STM32F4x7_ETH_Driver\inc; lib\stm32_mw_lwip\src\include; lib\stm32_mw_lwip\system; src; src\ethernet
  ICCARM.CCOptLevel: 1
  ILINK.IlinkOutputFile: stm32++.out
configuration stm32f405xx (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F405xx; NO_EXCEPTIONS; NO_RTTI
  ICCARM.CCIncludePath2: lib\CMSIS\Device\ST\STM32F4xx\Include; src
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: stm32++.out
  group (top)
    src/: absoluteencoder.h adc.cpp adc.h adc303.cpp adc303.h analogservo.cpp analogservo.h as5040master.cpp as5040master.h button.cpp button.h buzzer.cpp buzzer.h can.cpp can.h caninterface.cpp caninterface.h cansocket.cpp cansocket.h compf3.cpp compf3.h cpuid.cpp cpuid.h dac.cpp dac.h dac37x.cpp dac37x.h dac4xx.h dma.h dma0fxx.cpp dma0fxx.h dma303x8.cpp dma303x8.h dma37x.cpp dma37x.h dma4xx.cpp dma4xx.h dma_l4.cpp dma_l4.h encoder.cpp encoder.h fakeeeprom.cpp fakeeeprom.h fdcan.cpp fdcan.h flash.h flash37x.cpp flash37x.h flash4xx.cpp flash4xx.h flashdrive.cpp flashdrive.h fmc.cpp fmc.h gpio.cpp gpio.h gpioconfig0.h gpioconfig3.h gpioconfig4.h gpioconfig_g4.h hardwaretimer.cpp hardwaretimer.h i2c.cpp i2c.h i2c_rev03.cpp i2s.cpp i2s.h imu.cpp imu.h led.cpp led.h led7.cpp led7.h motorDC.cpp motorDC.h picontroller.cpp picontroller.h powermanager.cpp powermanager.h precisetimer.cpp precisetimer.h pwminput.cpp pwminput.h pwmout.cpp pwmout.h rcc.cpp rcc.h rgbled.cpp rgbled.h rotaryencoder.cpp rotaryencoder.h sdadc.cpp sdadc.h spi.cpp spi.h stm32.h usart.cpp usart.h
  group 3rd_party/lwip
    lib/stm32_mw_lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group 3rd_party/lwip/ipv4
    lib/stm32_mw_lwip/src/core/ipv4/: acd.c autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group 3rd_party/lwip/netif
    lib/stm32_mw_lwip/src/netif/: ethernet.c
  group __startup
    lib/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f030x6.s
    lib/CMSIS/Device/ST/cmsis_device_f3/Source/Templates/iar/: startup_stm32f303x8.s startup_stm32f303xc.s
    lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40xx.s startup_stm32f429_439xx.s
    lib/CMSIS/Device/ST/cmsis_device_f7/Source/Templates/iar/: startup_stm32f767xx.s
    lib/CMSIS/Device/ST/STM32G4xx/Source/Templates/iar/: startup_stm32g474xx.s
    lib/CMSIS/Device/ST/STM32L4xx/Source/Templates/iar/: startup_stm32l476xx.s
  group _doxygen
    doxygen/: Doxyfile mainpage.md
  group audio
    src/audio/: amicrophone.cpp amicrophone.h aspeaker.cpp aspeaker.h audiodev.cpp audiodev.h audioformat.h i2smicrophone.cpp i2smicrophone.h microphone.cpp microphone.h sequencer.cpp sequencer.h speaker.cpp speaker.h
  group canopen
    src/canopen/: canopencommon.h canopendevice.cpp canopendevice.h canopenlite.cpp canopenlite.h canopenmaster.cpp canopenmaster.h canopenproxy.cpp canopenproxy.h objdict.h
  group core
    src/core/: advmath.cpp advmath.h application.cpp application.h bytearray.cpp bytearray.h closure.h closure_impl.h core.cpp core.h coreexception.h coretypes.h device.cpp device.h macros.h qdebug.cpp qdebug.h quaternion.cpp quaternion.h qvector3d.h ringbuffer.h sfs.cpp sfs.h timer.cpp timer.h
  group device
    src/device/: ad5412.cpp ad5412.h ad7888.cpp ad7888.h ads1220.c ads1220.h adxl345.cpp adxl345.h as5047d.cpp as5047d.h battery.h bmx055.cpp bmx055.h dac124s085.cpp dac124s085.h drv8320.cpp drv8320.h drv8711.cpp drv8711.h ds18b20.cpp ds18b20.h eeprom24c.h ft6336.cpp ft6336.h gpioexpander.cpp gpioexpander.h hd44780.c hd44780.h ili9341.cpp ili9341.h ili9486.cpp ili9486.h max31855.cpp max31855.h mt6818.cpp mt6818.h mt6825.cpp mt6825.h mt6835.cpp mt6835.h shiftregister.cpp shiftregister.h st7735.cpp st7735.h st7796.cpp st7796.h stmpe811.cpp stmpe811.h tm7711.cpp tm7711.h touchpanel.cpp touchpanel.h xpt2046.cpp xpt2046.h
  group ethernet
    src/ethernet/: ethernet.cpp ethernet.h httpserver.cpp httpserver.h jsonvalue.cpp jsonvalue.h tcpserver.cpp tcpserver.h tcpsocket.cpp tcpsocket.h udpsocket.cpp udpsocket.h
  group ethernet/port
    src/ethernet/: lwipopts.h stm32f4x7_eth.c stm32f4x7_eth.h stm32f4x7_eth_conf.h
  group gfx
    src/gfx/: color.h display.cpp display.h dma2d.cpp dma2d.h font.cpp font.h fontdatabase.cpp fontdatabase.h fontinfo.h framebuffer.cpp framebuffer.h gradient.cpp gradient.h image.cpp image.h lcddisplay.cpp lcddisplay.h rect.h touchscreen.cpp touchscreen.h
  group gfx/gui
    src/gfx/gui/: abstractspinbox.cpp abstractspinbox.h flexlayout.h floatspinbox.cpp floatspinbox.h font_Tahoma_13.cpp gaugebarwidget.cpp gaugebarwidget.h gaugewidget.cpp gaugewidget.h gridlayout.h guiapplication.cpp guiapplication.h guitypes.h label.cpp label.h layout.h ledwidget.cpp ledwidget.h lineedit.cpp lineedit.h listspinbox.cpp listspinbox.h pagelayout.h palette.h progressbar.cpp progressbar.h pushbutton.cpp pushbutton.h spinbox.cpp spinbox.h switchbutton.cpp switchbutton.h translator.cpp translator.h widget.cpp widget.h widgets.h
  group modbus
    src/modbus/: commonproxy.cpp commonproxy.h genericdevice.cpp genericdevice.h modbus.cpp modbus.h modbus485.cpp modbus485.h modbusdevice.cpp modbusdevice.h modbusmaster.cpp modbusmaster.h modbusproxy.cpp modbusproxy.h modbusslave.cpp modbusslave.h modbustcp.cpp modbustcp.h modbustransport.cpp modbustransport.h
  group objnet
    src/objnet/: canonbinterface.cpp canonbinterface.h genericonbinterface.cpp genericonbinterface.h objectinfo.cpp objectinfo.h objnetclasses.h objnetcommon.h objnetCommonNode.cpp objnetCommonNode.h objnetdevice.cpp objnetdevice.h objnetInterface.cpp objnetInterface.h objnetmaster.cpp objnetmaster.h objnetmsg.cpp objnetmsg.h objnetnode.cpp objnetnode.h objnetstorage.cpp objnetstorage.h onbupgrader.cpp onbupgrader.h onbvirtualinterface.cpp onbvirtualinterface.h radioonbinterface.cpp radioonbinterface.h uartonbinterface.cpp uartonbinterface.h udponbinterface.cpp udponbinterface.h usbhidonbinterface.cpp usbhidonbinterface.h
  group radio
    src/radio/: cc1200.cpp cc1200.h cc1200_const.h radiointerface.cpp radiointerface.h
  group serial
    src/serial/: esp8266.cpp esp8266.h serialframe.cpp serialframe.h serialinterface.h seriallink.cpp seriallink.h usartframed.cpp usartframed.h usbvcp.cpp usbvcp.h
  group usb
    src/usb/: usb.h usbcfg.cpp usbcfg.h usbconst.h usbdesc.cpp usbdesc.h usbdev.cpp usbdev.h usbdevdrv.cpp usbdevdrv.h usbep.cpp usbep.h usbif.cpp usbif.h usbifcol.cpp usbifcol.h usbnode.cpp usbnode.h usbreq.cpp usbreq.h
  group usb/otgDriver
    src/usb/otgDriver/: usb_bsp.h usb_conf.h usb_core.cpp usb_core.h usb_defines.h usb_regs.h
  group usb/usbAudio
    src/usb/usbAudio/: usbaudio.cpp usbaudio.h usbaudiodesc.h
  group usb/usbCdc
    src/usb/usbCdc/: usbcdc.cpp usbcdc.h
  group usb/usbHid
    src/usb/usbHid/: hiditem.h hidusage.h usbhid.cpp usbhid.h
  group usb/usbMsc
    src/usb/usbMsc/: mscbot.cpp mscbot.h scsi.cpp scsi.h scsiinterface.cpp scsiinterface.h usbmsc.cpp usbmsc.h
  group usb/usbVideo
    src/usb/usbVideo/: usbVideo.cpp usbvideo.h
