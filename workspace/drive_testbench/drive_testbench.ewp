# IAR project drive_testbench.ewp, settings and files
configuration stm32f4discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F407xx
  ICCARM.CCIncludePath2: ; D:\projects\iar\components\robowtyku; $STM32PP_ROOT$\src; $STM32PP_ROOT$\src\core; $STM32PP_ROOT$\lib\stm32_mw_lwip\src\include; $STM32PP_ROOT$\lib\stm32_mw_lwip\system
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: lagrange_cb.srec
  ILINK.IlinkOutputFile: drive_testbench.out
  ILINK.IlinkIcfFile: stm32f4xx_flash_discovery.icf
  ILINK.IlinkAdditionalLibs: $STM32PP_ROOT$/bin/stm32f407vg/stm32++.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration china_kit (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F407xx; CHINA_KIT
  ICCARM.CCIncludePath2: ; D:\projects\iar\components\robowtyku; D:\projects\iar\components\stm32++\src; D:\projects\iar\components\stm32++\src\core; D:\projects\iar\components\stm32++\lib\stm32_mw_lwip\src\include; D:\projects\iar\components\stm32++\lib\stm32_mw_lwip\system
  group (top)
    ./: app.cpp app.h main.cpp
  group robowtyku
    ./: abstractdrive.h linearanalyzer.cpp linearanalyzer.h signalgenerator.cpp signalgenerator.h
  group robowtyku/drives
    motors/: canopendrive.cpp canopendrive.h encosdrive.cpp encosdrive.h
  group stm32f4xx
    ./: stm32f4xx_flash_discovery.icf
